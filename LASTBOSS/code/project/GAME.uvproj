# Keil uVision project GAME.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 塔防游戏 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 LM4229.c 通用函数.c 塔防游戏.h main.c digitaltube.c Dcommunication_R.c gamemain.c picture.c lcdziku.c EEPROM.c select.c guangqiasheji.c Buzzer.c
